# Keil uVision project eIDTMU_Uv2_Uv2.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: tmu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: main;include;mcu;uart;command;eeprom;ledProcess;update;crc;delay;timer;tmu_number;
  group Source Group 1
    ./: STARTUP.A51
    ./main/: main.c variable.c share.c hardInfo.c
    ./MCU/: mcuInit.c
    ./uart/: uart1.c
    ./command/: netCommand.c
    ./eeprom/: idProcess.c tmuProcess.c ds2431Process.c oneWireProcess.c
    ./ledProcess/: ledStatus.c
    ./update/: update.c
    ./crc/: crc.c
    ./delay/: delay.c
    ./timer/: timer.c
    ./tmu_number/: tmunum.c
